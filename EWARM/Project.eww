<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\scheduler_sim7020.ewp</path>
  </project>
  <batchBuild />
</workspace>
